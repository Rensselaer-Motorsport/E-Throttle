# Keil uVision project PSoC_Eye_PSoC4lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: "IRAM(0x20000000-0x20000FFF)IROM(0x0-0x7FFF)CLOCK(48000000)CPUTYPE( "Cortex-M0") ESEL ELITTLE"
  output: PSoC_Eye_PSoC4lib (library)
  group Source Files
    ./Generated_Source/PSoC4/: cyfitter_cfg.h cyfitter_cfg.c cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h PAN.c PAN.h PAN_PM.c TILT.c TILT.h TILT_PM.c H100.c H100.h PAN_O.c PAN_O.h PAN_O_aliases.h TILT_O.c TILT_O.h TILT_O_aliases.h cm0gcc.ld Cm0RealView.scat core_cm0_psoc4.h core_cm0.c core_cm0.h CyBootAsmGnu.s CyFlash.c CyFlash.h CyLib.c CyLib.h cyPm.c cyPm.h cytypes.h cyutils.c cypins.h project.h I2CM.c I2CM.h I2CM_I2C.h I2CM_I2C_INT.c I2CM_I2C.c I2CM_I2C_BOOT.c I2CM_I2C_MASTER.c I2CM_PM.c I2CM_BOOT.c I2CM_PINS.h I2CM_I2C_PVT.h I2CM_PVT.h I2CM_SCB_IRQ.c I2CM_SCB_IRQ.h I2CM_SCBCLK.c I2CM_SCBCLK.h I2CM_scl.c I2CM_scl.h I2CM_scl_aliases.h I2CM_sda.c I2CM_sda.h I2CM_sda_aliases.h RESET.c RESET.h RESET_aliases.h CLOCK.c CLOCK.h CLOCK_aliases.h
target Release (ARM-GNU)
  device: CY8C4245AXI-483 Cypress
  cpu: as above
  output: PSoC_Eye_PSoC4lib (library)
